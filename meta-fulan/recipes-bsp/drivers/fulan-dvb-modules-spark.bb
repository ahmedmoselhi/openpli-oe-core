require fulan-dvb-modules.inc

PR = "${INC_PR}"

SRCDATE = "20190921"

COMPATIBLE_MACHINE = "spark"
