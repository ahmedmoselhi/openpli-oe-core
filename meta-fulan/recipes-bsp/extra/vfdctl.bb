require ddt-apps.inc

CPPFLAGS += "-DHAVE_SPARK7162_HARDWARE"
